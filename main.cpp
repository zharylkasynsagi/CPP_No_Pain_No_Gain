#include <iostream>
#include <string>
#include <thread> // Для задержек в Модуле 3
#include <chrono> // Для работы со временем

using namespace std;

// Вспомогательная функция для безопасного ввода чисел (защита от некорректных типов)
void clearInput() {
    cin.clear();
    cin.ignore(10000, '\n');
}

// Старые функции из СРС1
void showWorkSchedule() {
    cout << "\n========================================\n";
    cout << "   1. РЕГЛАМЕНТ РАБОЧЕГО ВРЕМЕНИ\n";
    cout << "========================================\n";
    cout << "Лаборант кабинета ИКТ работает на 0,5 ставки.\n";
    cout << "Обязательный объем рабочего времени:\n";
    cout << "20 часов в неделю.\n";
    cout << "========================================\n";
}

void showSoftwareCheck() {
    cout << "\n========================================\n";
    cout << "   2. ПРОВЕРКА ПРОГРАММНОГО ОБЕСПЕЧЕНИЯ\n";
    cout << "========================================\n";
    cout << "Лаборант обязан ежедневно проверять\n";
    cout << "работоспособность программного обеспечения\n";
    cout << "на всех ноутбуках компьютерного класса\n";
    cout << "ДО начала занятий.\n";
    cout << "========================================\n";
}

void showMaterialResponsibility() {
    cout << "\n========================================\n";
    cout << "   3. МАТЕРИАЛЬНАЯ ОТВЕТСТВЕННОСТЬ\n";
    cout << "========================================\n";
    cout << "Лаборант отвечает за сохранность имущества\n";
    cout << "компьютерного класса в пределах своих\n";
    cout << "должностных обязанностей.\n";
    cout << "\nНеобходимо:\n";
    cout << "- бережно относиться к ноутбукам и оборудованию;\n";
    cout << "- контролировать сохранность имущества;\n";
    cout << "- своевременно сообщать о неисправностях\n";
    cout << "  или повреждениях оборудования.\n";
    cout << "========================================\n";
}

// --- НОВЫЕ МОДУЛИ СРС №2 ---

// МОДУЛЬ 1: Учет рабочего времени и блокировка
void moduleWorkTimeValidation() {
    cout << "\n========================================\n";
    cout << "   МОДУЛЬ 1: УЧЕТ РАБОЧЕГО ВРЕМЕНИ\n";
    cout << "========================================\n";

    int days = 0;
    double rate = 0.0;
    int hoursPerDay = 0;

    cout << "Введите количество рабочих дней в неделе (ожидается 5): ";
    while (!(cin >> days)) {
        cout << "Ошибка ввода! Введите число: ";
        clearInput();
    }

    cout << "Введите ставку (ожидается 0.5): ";
    while (!(cin >> rate)) {
        cout << "Ошибка ввода! Введите число: ";
        clearInput();
    }

    // Цикл блокировки
    do {
        cout << "Введите количество рабочих часов в день: ";
        while (!(cin >> hoursPerDay)) {
            cout << "Ошибка ввода! Введите число: ";
            clearInput();
        }

        if (hoursPerDay == 2) {
            cout << "\n---------------------------------------------------\n";
            cout << "Ошибка! При 5-дневной рабочей неделе 2 часа в день\n";
            cout << "составляют 10 часов в неделю. Дефицит рабочего времени:\n";
            cout << "10 часов (50% от нормы 0.5 ставки). Налицо факт\n";
            cout << "предоставления заведомо ложных сведений работодателю.\n";
            cout << "---------------------------------------------------\n";
            cout << "ДОСТУП ЗАБЛОКИРОВАН! Введите корректную норму (4 часа в день).\n\n";
        } else if (hoursPerDay != 4) {
            cout << "Некорректная норма для 0.5 ставки. Подтвердите норму в 4 часа в день.\n\n";
        }
    } while (hoursPerDay != 4);

    cout << "\n[ОК] Норма в 4 часа в день (20 часов/неделю) подтверждена.\n";
}
// МОДУЛЬ 2: Дисциплинарные взыскания
void moduleDisciplinarySanctions() {
    int laptopNum = 0;
    cout << "\n========================================\n";
    cout << "   МОДУЛЬ 2: ДИСЦИПЛИНАРНЫЕ ВЗЫСКАНИЯ\n";
    cout << "========================================\n";
    cout << "Введите номер ноутбука, фигурирующего в инциденте: ";
    while (!(cin >> laptopNum)) {
        cout << "Ошибка ввода! Введите номер: ";
        clearInput();
    }

    cout << "\n---------------------------------------------------\n";
    cout << "ИНЦИДЕНТ: Самовольный вынос учебного, настроенного\n";
    cout << "ноутбука #" << laptopNum << " за пределы учебного кабинета\n";
    cout << "и срыв учебного процесса.\n\n";
    cout << "ПРАВОВОЕ НАПОЛНЕНИЕ (Устав ВУЗа):\n";
    cout << " 1. Пункт 4.1: Грубое нарушение трудовой дисциплины.\n";
    cout << " 2. Пункт 4.5: Умышленный саботаж учебного процесса.\n";
    cout << " 3. Пункт 5.2: Несоответствие сотрудника занимаемой должности.\n";
    cout << "---------------------------------------------------\n";
}

// МОДУЛЬ 3: Протокол реагирования на саботаж (с задержками времени)
void moduleSabotageProtocol() {
    int laptopNum = 0;
    cout << "\n========================================\n";
    cout << "   МОДУЛЬ 3: ПРОТОКОЛ РЕАГИРОВАНИЯ НА САБОТАЖ\n";
    cout << "========================================\n";
    cout << "Укажите номер ноутбука: ";
    while (!(cin >> laptopNum)) {
        cout << "Ошибка ввода! Введите номер: ";
        clearInput();
    }

    cout << "\n[Запуск протокола в реальном времени...]\n\n";

    cout << "1. Фиксация нарушения: Обнаружен факт неисполнения обязанностей /\n"
         << "   несанкционированного выноса оборудования (ноутбук #" << laptopNum << ") /\n"
         << "   утери материальных ценностей (блок питания) / отказ в выполнении своих\n"
         << "   функциональных обязанностей – подготовки и тестирования ПО кабинета ИКТ /\n"
         << "   соблюдения учебной дисциплины.\n";
    std::this_thread::sleep_for(std::chrono::seconds(2));

    cout << "\n2. Уведомление руководства: Действие преподавателя: Официальное\n"
         << "   письменное или устное уведомление ответственного лица,\n"
         << "   закрепленного за кабинетом ИКТ.\n";
    std::this_thread::sleep_for(std::chrono::seconds(2));

    cout << "\n3. Проверка доказательной базы: Действие: Инициирование запроса\n"
         << "   на аудит записей камер видеонаблюдения. Сопоставление с логами посещения кабинета.\n";
    std::this_thread::sleep_for(std::chrono::seconds(2));

    cout << "\n4. Подача служебной записки: Действие преподавателя: Направление официальной\n"
         << "   служебной записки на имя заведующего кафедрой / руководителя конструкторского\n"
         << "   отдела и декана факультета с подробным описанием инцидента\n"
         << "   (включая срыв учебного процесса и \"цирк\" на СРС).\n";
    std::this_thread::sleep_for(std::chrono::seconds(2));

    cout << "\n5. Административные последствия: Итог протокола: Создание дисциплинарной\n"
         << "   комиссии, вынесение выговора, расторжение трудового договора по статье\n"
         << "   (0.5 ставки) с последующей передачей дела в органы материального учета ВУЗа.\n";
    std::this_thread::sleep_for(std::chrono::seconds(1));
    cout << "\n[Протокол завершен]\n";
}

// Старая функция контрольного вопроса
void controlQuestion() {
    int answer;
    cout << "\n========================================\n";
    cout << "       КОНТРОЛЬНЫЙ ВОПРОС\n";
    cout << "========================================\n";

    do {
        cout << "Сколько часов в неделю обязан отрабатывать\n";
        cout << "лаборант на 0,5 ставки? ";
        while (!(cin >> answer)) {
            cout << "Ошибка ввода! Введите число: ";
            clearInput();
        }

        if (answer == 20) {
            cout << "\nПравильно! Ответ: 20 часов.\n";
            cout << "Контроль усвоения пройден.\n";
        } else {
            cout << "\nНеверный ответ. Попробуйте еще раз.\n\n";
        }

    } while (answer != 20);
}
int main() {
    int choice;

    cout << "========================================\n";
    cout << "       ИНФОРМАЦИОННЫЙ БОТ\n";
    cout << "       ЛАБОРАНТА КАБИНЕТА ИКТ\n";
    cout << "========================================\n";
    cout << "Тема: \"When life gives you lemons, make lemonade\"\n";

    do {
        cout << "\n------------- МЕНЮ ----------------\n";
        cout << "1. Регламент рабочего времени\n";
        cout << "2. Проверка программного обеспечения\n";
        cout << "3. Материальная ответственность\n";
        cout << "4. Проверка рабочего времени (Модуль 1)\n";
        cout << "5. Дисциплинарные взыскания (Модуль 2)\n";
        cout << "6. Протокол реагирования на саботаж (Модуль 3)\n";
        cout << "7. Завершить ознакомление и пройти контроль\n";
        cout << "-----------------------------------\n";
        cout << "Выберите пункт меню: ";

        if (!(cin >> choice)) {
            cout << "\nОшибка! Вводите только числа.\n";
            clearInput();
            continue;
        }

        switch (choice) {
            case 1: showWorkSchedule(); break;
            case 2: showSoftwareCheck(); break;
            case 3: showMaterialResponsibility(); break;
            case 4: moduleWorkTimeValidation(); break;
            case 5: moduleDisciplinarySanctions(); break;
            case 6: moduleSabotageProtocol(); break;
            case 7:
                cout << "\nПереходим к контрольному вопросу...\n";
                controlQuestion();
                break;
            default:
                cout << "\nОшибка! Такого пункта меню нет.\n";
                cout << "Выберите число от 1 до 7.\n";
        }

    } while (choice != 7);

    return 0;
}